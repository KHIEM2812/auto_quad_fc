<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UserProject\STM32F10x_UserProjectRTOS.ewp</path>
  </project>
</workspace>


