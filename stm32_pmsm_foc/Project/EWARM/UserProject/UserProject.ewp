# IAR project UserProject.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL; USE_STM32100B_EVAL
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL; ..\..\..\MC library\interface\common\; ..\..\..\MC Application\interface\; ..\..\..\System & Drive Params\; ..\..\..\UI Library\interface\; ..\..\..\UI Library\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UserProject.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f100xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\..\..\MC library\interface\common\; ..\..\..\MC Application\interface\; ..\..\..\System & Drive Params\; ..\..\..\UI Library\interface\; ..\..\..\UI Library\inc\
  ILINK.IlinkIcfFile: stm32f10xE_flash.icf
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL; ..\..\..\MC library\interface\common\; ..\..\..\MC Application\interface\; ..\..\..\System & Drive Params\; ..\..\..\UI Library\interface\; ..\..\..\UI Library\inc\
  ILINK.IlinkIcfFile: stm32f10xB_flash.icf
configuration STEVAL-IHM022V1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STEVAL_IHM022V1
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f10xE_flash.icf
  group (top)
    ../../: main.c stm32f10x_it.c Timebase.c UITask.c
    ../../../: readme.txt
    ../../../System & Drive Params/: stm32f10x_MC_it.c
  group Motor control/MC Application
    ../MC Application Compiled/Exe/: MC Application.a
  group Motor control/MC Application/interface
    ../../../MC Application/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group Motor control/MC Library
    ../MC Library Compiled/Exe/: MC_Library_dual_drive.a MC_Library_single_drive.a
  group Motor control/MC Library/interface/common
    ../../../MC library/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h
  group Std project template/CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Std project template/Doc
    ./: readme.txt
  group Std project template/EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group Std project template/StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Std project template/STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group User interface/UI Library/interface
    ../../../UI Library/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group User interface/UI Library/private
    ../../../UI Library/inc/: DAC_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group User interface/UI Library/src
    ../../../UI library/src/: DAC_UserInterfaceClass.c DACRCTIMER_UserInterfaceClass.c DACSPI_UserInterfaceClass.c DACSPIAD7303_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c USART_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
