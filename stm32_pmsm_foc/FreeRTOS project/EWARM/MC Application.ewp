# IAR project MC Application.ewp, settings and files
configuration RELEASE (ARM)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_DAC; USE_LCD
  ICCARM.CCIncludePath2: ..\; ..\..\MC library\interface\; ..\..\MC library\interface\common\; ..\..\MC Application\; ..\..\MC Application\inc\; ..\..\MC Application\interface\; ..\..\System & Drive Params\; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group MC Application/interface
    ../../MC Application/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group MC Application/private
    ../../MC Application/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MC Application/src
    ../../MC Application/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group MC Library/interface
    ../../MC library/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FOCDriveClass.h HALL_SpeednPosFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h IMF_PMSM_FOCDriveClass.h IMFF_PMSM_FOCDriveClass.h NTC_TemperatureSensorClass.h PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SM_PMSM_FOCDriveClass.h SMF_PMSM_FOCDriveClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group MC Library/interface/common
    ../../MC library/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h
  group System & Drive Params
    ../../System & Drive Params/: SystemNDriveParams.h
  group System & Drive Params/Motor1
    ../../System & Drive Params/: Control stage parameters.h Drive parameters.h Parameters conversion.h PMSM motor parameters.h Power stage parameters.h
  group System & Drive Params/Motor2
    ../../System & Drive Params/: Control stage parameters motor 2.h Drive parameters motor 2.h Parameters conversion motor 2.h PMSM motor 2 parameters.h Power stage parameters motor 2.h
